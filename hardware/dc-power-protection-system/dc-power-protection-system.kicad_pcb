# Repository DontMindMe129/dc-power-protection-system (continued)

## KiCad design hardware/dc-power-protection-system/dc-power-protection-system.kicad_pcb (continued)

Board: 2 copper layers, 143 parts (0 on the bottom side), 65 nets, no tracks yet.

File hardware/dc-power-protection-system/bom.csv (part):

"Refs","Value","Footprint","Voltage","Tolerance","Power","MPN","Purchase_URL","Qty"
"A1","BluePill_STM32F103C8T6","Package_DIP:DIP-40_W15.24mm_Socket_LongPads","","","","MKE-K06 STM32F103C8T6 Blue Pill","https://hshop.vn/mach-phat-trien-mke-k06-stm32f103c8t6-blue-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","1"
"C1,C3,C4,C9,C11,C18,C21","100nF","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","50V","10%","","","https://icdayroi.com/tu-dien-100nf-50v-0805","7"
"C2","10uF","Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder","50V","10%","","","https://icdayroi.com/tu-dien-10uf-50v-1206-goi-10-con","1"
"C5,C6,C7","22uF","Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder","16V","10%","","","https://icdayroi.com/tu-dien-22uf-16v-1206-goi-10-con","3"
"C8,C14","10uF","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","50V","10%","","","https://icdayroi.com/tu-dien-10uf-50v-0805","2"
"C12,C13,C22,C23,C24,C25","10nF","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","50V","10%","","","https://icdayroi.com/tu-dien-10nf-50v-0805","6"
"C17","22nF","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","50V","10%","","","https://icdayroi.com/tu-dien-22nf-50v-0805","1"
"C19","10nF","Capacitor_THT:C_Rect_L7.2mm_W2.5mm_P5.00mm","100V","","","","https://icdayroi.com/tu-mica-2a103j-10nf-100v","1"
"C20","470pF","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","50V","","","","https://icdayroi.com/tu-dien-470pf-50v-0805","1"
"D1,D15,D19","SMBJ15CA","Diode_SMD:D_SMB","","","","SMBJ15CA","https://icdayroi.com/diode-tvs-smbj15ca-15v-600w-smb","3"
"D2,D3","1N4742A","Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal","12V","","1W","1N4742A","https://icdayroi.com/1n4742a","2"
"D4,D20,D21","SS14","Diode_SMD:D_SMA","","","","SS14","https://icdayroi.com/ss14","3"
"D5","1N4744A","Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal","15V","","1W","1N4744A","https://icdayroi.com/1n4744a","1"
"D6,D7,D8,D11,D12,D13,D18","BAS70WT","Package_TO_SOT_SMD:SOT-323_SC-70","","","","BAS70WT-TP","https://shopee.vn/50-Chi%C3%AA%CC%81c-BAS70-BAS70WT-TP-Schot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","7"
"D9,D10,D14","1N4148","Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal","","","","1N4148","https://icdayroi.com/1n4148-dip","3"
"D16","SS34C","Diode_SMD:D_SMC","","","","SS34 (SMC)","https://icdayroi.com/diode-ss34-3a-40v-smc-1n5822-ss34c","1"
"D17","1N4733A","Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal","5.1V","","1W","1N4733A","https://icdayroi.com/1n4733a","1"
"F1","F4A","Fuse:Fuseholder_Clip-5x20mm_Littelfuse_111_Inline_P20.00x5.00mm_D1.05mm_Horizontal","","","","5x20 mm glass fuse F4A 250V","https://www.thegioiic.com/cau-chi-ong-thuy-tinh-4a-5x20mm-toc-do-f","1"
"J1","DC_IN","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal","","","","KF301-2P 5.0 mm","https://icdayroi.com/kf301-2p-5-0mm","1"
"J2","LOAD_OUT","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal","","","","KF301-2P 5.0 mm","https://icdayroi.com/kf301-2p-5-0mm","1"
"J3","OLED_I2C","Connector_PinSocket_2.54mm:PinSocket_1x04_P2.54mm_Vertical","","","","Female header 1x4 (cut from 1x20)","https://icdayroi.com/header-1x20-2-54mm-female","1"
"J4","UART_DEBUG","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","","","","","https://icdayroi.com/header-1x40-2-54mm-male","1"
"L1","22uH","Inductor_SMD:L_Changjiang_FXL0630","","","","22uH molded 0630 (7x7x3 mm)","https://icdayroi.com/cuon-cam-22uh-0630","1"
"L2","4.7uH","Inductor_SMD:L_Changjiang_FXL0630","","","","4.7uH molded 0630 (7x7x3 mm)","https://icdayroi.com/cuon-cam-4-7uh-0630","1"
"Q1,Q2","AO4435-VB","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","","","","AO4435-VB","https://www.thegioiic.com/ao4435-vb-mosfet-kenh-p-30v-7a-8-soic","2"
"Q3,Q4","AOD4185","Package_TO_SOT_SMD:TO-252-2","","","","AOD4185","https://www.thegioiic.com/aod4185-mosfet-kenh-p-40v-40a-to-2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","2"
"Q5,Q6","2N3904","Package_TO_SOT_THT:TO-92_Inline","","","","2N3904","https://icdayroi.com/2n3904","2"
"Q7,Q9","AO3400A","Package_TO_SOT_SMD:SOT-23","","","","AO3400A (UMW)","https://icdayroi.com/ao3400a-mosfet-sot23-3-n-1ch-5a-30v-umw","2"
"R1,R10","100k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-100k-0805-1-goi-50-con","2"
"R2","2.2k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-2k2-0805-1-goi-50-con","1"
"R3,R5,R15,R20,R28,R41,R42,R43,R44","10k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-10k-0805-1-goi-50-con","9"
"R4","120k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-120k-0805-1-goi-50-con","1"
"R6","10M","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","","1%","0.25W","","https://icdayroi.com/dien-tro-10m-1-4w-1-goi-10-con","1"
"R7,R8,R12","22k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-22k-0805-1-goi-50-con","3"
"R9","1k","Resistor_THT:R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal","","1%","1W","","https://icdayroi.com/dien-tro-1k-1w-1","1"
"R11","18k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-18k-0805-1-goi-50-con","1"
"R13","3k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","","1%","0.25W","","https://icdayroi.com/dien-tro-3k-1-4w-1-goi-50-con","1"
"R14","0.01","Resistor_SMD:R_2512_6332Metric_Pad1.40x3.35mm_HandSolder","","1%","2W","","https://icdayroi.com/dien-tro-r010-2512-2w-1","1"
"R16,R18","15k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-15k-0805-1-goi-50-con","2"
"R17","12k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-12k-0805-1-goi-50-con","1"
"R19","680","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-680-ohm-0805-1-goi-50-con","1"
"R21,R53,R56,R59,R60,R61,R63","47k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-47k-0805-1-goi-50-con","7"
"R22,R23","100","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-100-ohm-0805-1-goi-50-con","2"
"R24,R58","2.2M","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","","1%","0.25W","","https://icdayroi.com/dien-tro-2m2-1-4w-1-goi-10-con","2"
"R25,R30","220k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-220k-0805-1-goi-50-con","2"
"R26","1k","Resistor_THT:R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal","","5%","0.5W","","https://icdayroi.com/dien-tro-1k-1-2w-5-goi-10-con","1"
"R27,R32,R34,R37,R62","1k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-1k-0805-1-goi-50-con","5"
"R29,R35,R36,R38","330","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","5%","0.125W","","https://icdayroi.com/dien-tro-330-ohm-0805-5-goi-50-con-1","4"
"R31,R33,R39,R40","3.3k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-3-3k-0805-1-goi-50-con","4"
"R45,R46","4.7k","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-4k7-0805-1-goi-50-con","2"
"R47","47","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-47-ohm-0805-1-goi-50-con","1"
"R54,R57","20k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","","1%","0.25W","","https://icdayroi.com/dien-tro-20k-1-4w-1-goi-50-con","2"
"R55","1M","Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder","","1%","0.125W","","https://icdayroi.com/dien-tro-1m-0805-1-goi-50-con","1"
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